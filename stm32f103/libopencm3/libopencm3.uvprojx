# Keil uVision project libopencm3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: libopencm3_f103 (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F1
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group comm
    ./lib/stm32/common/: crc_common_all.c dac_common_all.c dma_common_l1f013.c exti_common_all.c flash_common_f01.c gpio_common_all.c iwdg_common_all.c pwr_common_all.c rcc_common_all.c spi_common_all.c timer_common_all.c spi_common_l1f124.c adc_common_v1.c i2c_common_all.c usart_common_all.c usart_common_f124.c
  group cm3
    ./lib/cm3/: assert.c dwt.c nvic.c scb.c sync.c systick.c vector.c
  group source
    ./lib/stm32/f1/: adc.c crc.c dac.c dma.c ethernet.c flash.c gpio.c i2c.c iwdg.c pwr.c rcc.c rtc.c spi.c timer.c usart.c
